options:
  parameters:
    generate_options: qt_gui
    id: LinToCirc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '1.0'
    step: '0.005'
    stop: '2.1'
    value: '1.9'
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 953e6
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 955e6
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: Phase
    start: '-180'
    step: '0.25'
    stop: '180'
    value: '-80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '50e-3'
    freq: 2.2e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '50e-3'
    freq: 2.0e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7071067812'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7071067812'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7071067812'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7071067812'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: '90'
  states: {}
- name: blocks_phase_shift_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: '90'
  states: {}
- name: blocks_phase_shift_0_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phase
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 960e6
    fftsize: '1024'
    name: '"E_H"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 962e6
    fftsize: '1024'
    name: '"E_V"'
    showrf: 'True'
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_sink_1_0.set_time_source('_external_')
      self.uhd_usrp_source_0.set_time_source('_external_')
      self.uhd_usrp_sink_1_0.set_clock_source('external')
      self.uhd_usrp_source_0.set_clock_source('external')

      self.uhd_usrp_sink_1_0.set_time_next_pps(uhd.time_spec(0.0))
      self.uhd_usrp_source_0.set_time_next_pps(uhd.time_spec(0.0))

      time.sleep(2)

      nowtime = self.uhd_usrp_sink_1_0.get_time_now()
      self.uhd_usrp_sink_1_0.set_command_time(nowtime+uhd.time_spec(0.5))
      self.uhd_usrp_source_0.set_command_time(nowtime+uhd.time_spec(0.5))
      self.uhd_usrp_sink_1_0.set_center_freq(953e6, 0)
      self.uhd_usrp_sink_1_0.set_center_freq(955e6, 1)
      self.uhd_usrp_source_0.set_center_freq(955e6, 0)
      self.uhd_usrp_source_0.set_center_freq(953e6, 1)
      time.sleep(1)
      self.uhd_usrp_sink_1_0.clear_command_time()
      self.uhd_usrp_source_0.clear_command_time()

      now_time = self.uhd_usrp_sink_1_0.get_time_now()
      self.uhd_usrp_sink_1_0.set_command_time(nowtime+uhd.time_spec(0.5))
      self.uhd_usrp_source_0.set_command_time(nowtime+uhd.time_spec(0.5))

      self.uhd_usrp_sink_1_0.set_start_time(now_time+uhd.time_spec(3))
      self.uhd_usrp_source_0.set_start_time(now_time+uhd.time_spec(3))
      time.sleep(1)
      self.uhd_usrp_sink_1_0.clear_command_time()
      self.uhd_usrp_source_0.clear_command_time()
      print (uhd.time_spec_t.get_real_secs(now_time))
    section: main_after_init
  states: {}
- name: uhd_usrp_sink_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: freq1
    center_freq1: freq2
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=192.168.68.253, addr1=192.168.68.254"'
    gain0: '0.5'
    gain1: '0.5'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: freq2
    center_freq1: freq1
    clock_source0: external
    clock_source1: external
    dev_addr: '"addr0=192.168.68.253, addr1=192.168.68.254"'
    gain0: '1'
    gain1: '1'
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1]'
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_sub_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_phase_shift_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_1_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', qtgui_sink_x_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_phase_shift_0, '0', blocks_add_xx_0, '1']
- [blocks_phase_shift_0, '0', blocks_sub_xx_0, '1']
- [blocks_phase_shift_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_phase_shift_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_1, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_phase_shift_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_add_xx_0_0, '1']
- [uhd_usrp_source_0, '0', blocks_sub_xx_0_0, '1']
- [uhd_usrp_source_0, '1', blocks_phase_shift_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
